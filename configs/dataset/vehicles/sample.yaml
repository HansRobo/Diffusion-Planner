## configs/dataset/vehicles/sample.yaml
```yaml
sample:
  base_link_to_front: 3.79
  vehicle_length: 4.89
  vehicle_width: 1.896
```
